# IAR project wmdp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S3C2440A Samsung S3C2440A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\.; ..\src\include; ..\src\uCOS-II\Source; ..\src\uC-CPU\ARM\IAR-II\Source; ..\src\uC-CPU\ARM\IAR; ..\src\uC-CPU; ..\src\uC-LIB; ..\src\include; ..\src\libcpu\arm; ..\src\libcpu\arm\s3c24xx; ..\src\board\ethcan; ..\src\freertos\Source; ..\src\freertos\Source\include; ..\src\freertos\Source\portable; ..\src\freertos\Source\portable\IAR; ..\src\freertos\Source\portable\IAR\S3C24x0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wmdp.bin
  ILINK.IlinkOutputFile: bldc.out
  ILINK.IlinkIcfFile: UTU2440_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: bldc.srec
  group src/libcpu/arm/s3c24xx
    ../src/libcpu/arm/s3c24xx/: start_iar.s 2440slib.s 2440lib.c mmu.c uart0_s3c24xx.c
  group src/board/ethcan
    ../src/board/ethcan/: board.c s3c2440_isr.c
  group src/freertos/Source
    ../src/freertos/Source/: list.c croutine.c queue.c tasks.c timers.c
  group src/freertos/Source/portable/IAR/S3C24x0
    ../src/freertos/Source/portable/IAR/S3C24x0/: port.c portasm.s
